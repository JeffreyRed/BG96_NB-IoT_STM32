# Keil uVision project Low Power mode l073 RTC BG96.uvprojx, settings and files
target Low Power mode l073 RTC BG96 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Low Power mode l073 RTC BG96
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c
    ./: BG96.c RTC.c UART.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_rtc.c stm32l0xx_hal_uart.c
software components: CMSIS:CORE 4.1.0
